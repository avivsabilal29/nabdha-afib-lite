// ---------------------------------------------------------------------------
// tb_peak_detect.sv -- event stream bench for the Fase 5 stage (peak_detect).
//
// This is the Fase 5 archetype: the earlier benches compared a WORD stream against a
// golden column, this one compares an EVENT stream. Fase 5 emits, per detected peak,
// one event {sample index, envelope value, kind} on m_ev_valid, plus the introspection
// pair d_valid/d_thr/d_pk and the status word o_beat_count. Every one of those is
// checked against the frozen model's own export, not against a quantity recomputed
// here.
//
// EXPECTED DATA PROVENANCE. The expected arrays under +VECTOR=<dir> are generated by
//   rtl/tb/vektor/fase5-verifikasi-aviv/ekspor_vektor_puncak.py
// from the Fase 5 export of model/rantai-afib-lite/rantai.py, namely
//   <rtlplan2>/fase5/04015.peaks.csv   (sha256 500e6c0b8065544a220bc6c9a08fe64669137c7aa97d2e9a33c6bdf8d31e13a9)
// The .hex files are generated output and must never be edited by hand; re-run the
// script instead. The column mapping is:
//   sample_index   -> expected m_ev_idx    envelope_value -> expected m_ev_val
//   filtered_peak  -> expected d_pk        i1             -> expected d_thr
//   event_kind     -> expected beat/reject class
//
// INPUT DATA. The three stimulus columns come from the Fase 0 gold export, one 32 bit
// word per line, $readmemh compatible:
//   +GOLD=<dir>/04015.jendela.hex    -> s_tdata   (W_WIN  33 bit, word zero extended)
//   +GOLD=<dir>/04015.hp.hex         -> s_hp      (W_HP   26 bit, low bits of the word)
//   +GOLD=<dir>/04015.turunan.hex    -> s_besaran (W_DER  24 bit, low bits of the word)
//
// Plusargs: +VECTOR=<dir> expected arrays (required), +GOLD=<dir> stimulus columns
// (required), +LIMIT=<n> smoke pass over the first n samples.
//
// Reference numbers this record must reproduce (parent verified):
//   peaks 4777, beats 2596, census {qrs 2590, qrs_search_back 6, rejected_t 1909,
//   noise 272}, ambang_state [29, 6, 112, 6, 106, 0, 26, 1202, 2586].
//
// WHAT THIS BENCH CANNOT CHECK, and why (reported, not hidden):
//   1 The frozen event vocabulary has no code for a T wave rejection or for a noise
//     peak; m_ev_kind carries only EV_QRS / EV_PEAK_CAND. The four way census is
//     therefore checked at the reference model level and compared here only as the
//     two way split beat / rejected. The bench prints the four way census it loaded.
//   2 m_ev_kind carries no code for a search back refit either: the six refitted beats
//     arrive as EV_QRS, and their index is the peak index, so they are covered by the
//     index and value comparisons, not by a distinct kind.
//   3 Nothing on the frozen port list exposes spki, npki, spkf or npkf, so those four
//     ambang_state words can only be reached through i1 (d_thr), which is a function
//     of them. The nine way state is compared once, at the end of the record, through
//     the additive introspection bus.
// ---------------------------------------------------------------------------
// No file level timescale: the package carries none, and Verilator raises TIMESCALEMOD on a
// file level timescale here (same reason as the other testbenches).
`default_nettype none

module tb_peak_detect;

    localparam int unsigned W_WIN     = afib_lite_pkg::W_WIN;
    localparam int unsigned W_HP      = afib_lite_pkg::W_HP;
    localparam int unsigned W_DER     = afib_lite_pkg::W_DER;
    localparam int unsigned W_THR     = afib_lite_pkg::W_THR;
    localparam int unsigned W_IDX     = afib_lite_pkg::W_IDX;
    localparam int unsigned W_TUSER   = afib_lite_pkg::W_TUSER;
    localparam int unsigned W_EVKIND  = afib_lite_pkg::W_EVKIND;

    localparam integer N_MAX = 450000;   // samples in the whole record
    localparam integer P_MAX = 4777;     // peaks in the whole record
    localparam integer A_MAX = 9;        // ambang_state elements
    localparam integer DBG_W = 14;       // additive introspection bus, words

    // -----------------------------------------------------------------------
    // stimulus columns and expected arrays
    // -----------------------------------------------------------------------
    reg [31:0] mem_win [0:N_MAX-1];
    reg [31:0] mem_hp  [0:N_MAX-1];
    reg [31:0] mem_der [0:N_MAX-1];

    reg [31:0] exp_pos    [0:P_MAX-1];
    reg [31:0] exp_pv     [0:P_MAX-1];
    reg [31:0] exp_pkf    [0:P_MAX-1];
    reg [31:0] exp_i1     [0:P_MAX-1];
    reg [31:0] exp_isqrs  [0:P_MAX-1];
    reg [31:0] exp_qrsidx [0:P_MAX-1];
    reg [31:0] exp_kind   [0:P_MAX-1];
    reg [31:0] exp_amb    [0:A_MAX-1];

    // -----------------------------------------------------------------------
    // DUT
    // -----------------------------------------------------------------------
    reg                      clk;
    reg                      rst_n;
    reg  [W_WIN-1:0]         s_tdata;
    reg                      s_tvalid;
    reg                      s_tlast;
    reg  [W_TUSER-1:0]       s_tuser;
    reg  [W_IDX-1:0]         s_sample_idx;
    reg                      i_enable;
    reg                      i_clear_counters;
    reg  [W_HP-1:0]          s_hp;
    reg  [W_DER-1:0]         s_besaran;

    wire [W_WIN-1:0]         m_tdata;
    wire                     m_tvalid;
    wire                     m_overflow;
    wire                     m_tlast;
    wire [W_TUSER-1:0]       m_tuser;
    wire [W_IDX-1:0]         m_sample_idx;
    wire                     m_ev_valid;
    wire [W_EVKIND-1:0]      m_ev_kind;
    wire [W_IDX-1:0]         m_ev_idx;
    wire [31:0]              m_ev_val;
    wire                     d_valid;
    wire [W_THR-1:0]         d_thr;
    wire [W_THR-1:0]         d_pk;
    wire [31:0]              o_beat_count;
    wire [DBG_W*32-1:0]      d_dbg;
    wire                     d_dbg_valid;

    peak_detect dut (
        .clk_i          (clk),
        .rst_ni         (rst_n),
        .s_tdata        (s_tdata),
        .s_tvalid       (s_tvalid),
        .s_tlast        (s_tlast),
        .s_tuser        (s_tuser),
        .s_sample_idx   (s_sample_idx),
        .i_enable       (i_enable),
        .i_clear_counters (i_clear_counters),
        .m_tdata        (m_tdata),
        .m_tvalid       (m_tvalid),
        .m_overflow     (m_overflow),
        .m_tlast        (m_tlast),
        .m_tuser        (m_tuser),
        .m_sample_idx   (m_sample_idx),
        .m_ev_valid     (m_ev_valid),
        .m_ev_kind      (m_ev_kind),
        .m_ev_idx       (m_ev_idx),
        .m_ev_val       (m_ev_val),
        .d_valid        (d_valid),
        .d_thr          (d_thr),
        .d_pk           (d_pk),
        .o_beat_count   (o_beat_count),
        .s_hp           (s_hp),
        .s_besaran      (s_besaran),
        .d_dbg          (d_dbg),
        .d_dbg_valid    (d_dbg_valid)
    );

    // -----------------------------------------------------------------------
    // The event bus cannot express the four way census: its frozen vocabulary has one code
    // for a beat and one for a rejected peak. The class is therefore rebuilt from the
    // additive flag word, word 11 of d_dbg, whose bits 0, 2 and 3 line up one for one with
    // the golden columns signal, t_rejected and search_back. All six walk rows carry
    // signal 0, so the walk bit is tested first, and the rebuild is checked against the
    // same three golden columns in the vector generator.
    // -----------------------------------------------------------------------
    function [1:0] cls_of(input [2:0] flags);   // {search_back, t_rejected, signal}
        if (flags[2])      cls_of = 2'd1;   // qrs_search_back
        else if (flags[0]) cls_of = 2'd0;   // qrs
        else if (flags[1]) cls_of = 2'd2;   // rejected_t
        else               cls_of = 2'd3;   // noise
    endfunction

    wire [1:0] cls_w = cls_of({d_dbg[11*32 + 3], d_dbg[11*32 + 2], d_dbg[11*32]});

    // -----------------------------------------------------------------------
    // scrutinee state
    // -----------------------------------------------------------------------
    integer limit_n;
    integer expect_k;        // expected peaks inside the run
    integer drive_n;         // samples driven
    integer out_n;           // accepted words seen
    integer ev_n;            // peak events seen
    integer dv_n;            // introspection pulses seen
    integer ovf_n;           // cycles m_overflow was high
    integer i;

    integer mm_idx,   mm_val,   mm_kind;
    integer mm_thr,   mm_pk;
    integer mm_fwd_i, mm_fwd_d, mm_fwd_u, mm_fwd_t;
    integer mm_cls;
    integer mm_idx_beat;
    integer dbg_v_n;
    reg     done;

    reg [31:0] ev_kind_census [0:3];   // qrs, qrs_search_back, rejected_t, noise
    reg [31:0] ev_loaded_census [0:3];
    reg [31:0] ev_beat_seen;
    reg [31:0] flag_census [0:3];

    // -----------------------------------------------------------------------
    // clock
    // -----------------------------------------------------------------------
    initial begin
        clk = 1'b0;
        forever #5 clk = ~clk;
    end

    // -----------------------------------------------------------------------
    // load, drive, monitor
    // -----------------------------------------------------------------------
    reg [8*256-1:0] vdir;
    reg [8*256-1:0] gdir;
    reg [8*400-1:0] fpath;

    initial begin
        limit_n = N_MAX;
        if (!$value$plusargs("LIMIT=%d", limit_n)) limit_n = N_MAX;
        if (limit_n > N_MAX) limit_n = N_MAX;
        if (!$value$plusargs("VECTOR=%s", vdir)) begin
            $display("tb_peak_detect: FAIL no +VECTOR (want the expected array directory)");
            $fatal(1);
        end
        if (!$value$plusargs("GOLD=%s", gdir)) begin
            $display("tb_peak_detect: FAIL no +GOLD (want the stimulus column directory)");
            $fatal(1);
        end

        $sformat(fpath, "%0s/04015.puncak.pos.hex",    vdir); $readmemh(fpath, exp_pos);
        $sformat(fpath, "%0s/04015.puncak.pv.hex",     vdir); $readmemh(fpath, exp_pv);
        $sformat(fpath, "%0s/04015.puncak.pkf.hex",    vdir); $readmemh(fpath, exp_pkf);
        $sformat(fpath, "%0s/04015.puncak.i1.hex",     vdir); $readmemh(fpath, exp_i1);
        $sformat(fpath, "%0s/04015.puncak.isqrs.hex",  vdir); $readmemh(fpath, exp_isqrs);
        $sformat(fpath, "%0s/04015.puncak.eventkind.hex", vdir); $readmemh(fpath, exp_kind);
        $sformat(fpath, "%0s/04015.puncak.qrsidx.hex", vdir); $readmemh(fpath, exp_qrsidx);
        $sformat(fpath, "%0s/04015.ambang_akhir.hex",  vdir); $readmemh(fpath, exp_amb);

        $sformat(fpath, "%0s/04015.jendela.hex", gdir); $readmemh(fpath, mem_win);
        $sformat(fpath, "%0s/04015.hp.hex",      gdir); $readmemh(fpath, mem_hp);
        $sformat(fpath, "%0s/04015.turunan.hex", gdir); $readmemh(fpath, mem_der);

        // expected peaks inside the run: the expected array is ordered by sample index
        expect_k = 0;
        for (i = 0; i < P_MAX; i = i + 1)
            if (exp_pos[i] < limit_n) expect_k = expect_k + 1;

        for (i = 0; i < 4; i = i + 1) ev_loaded_census[i] = 32'd0;
        for (i = 0; i < P_MAX; i = i + 1)
            ev_loaded_census[exp_kind[i][1:0]] = ev_loaded_census[exp_kind[i][1:0]] + 32'd1;

        mm_idx = 0; mm_val = 0; mm_kind = 0; mm_thr = 0; mm_pk = 0;
        mm_fwd_i = 0; mm_fwd_d = 0; mm_fwd_u = 0; mm_fwd_t = 0; dbg_v_n = 0;
        mm_cls = 0; mm_idx_beat = 0;
        for (i = 0; i < 4; i = i + 1) flag_census[i] = 32'd0;
        done = 1'b0;
        ev_n = 0; dv_n = 0; out_n = 0; drive_n = 0; ovf_n = 0; ev_beat_seen = 32'd0;
        for (i = 0; i < 4; i = i + 1) ev_kind_census[i] = 32'd0;

        // reset
        rst_n = 1'b0;
        s_tdata = {W_WIN{1'b0}}; s_tvalid = 1'b0; s_tlast = 1'b0;
        s_tuser = {W_TUSER{1'b0}}; s_sample_idx = {W_IDX{1'b0}};
        i_enable = 1'b0; i_clear_counters = 1'b0;
        s_hp = {W_HP{1'b0}}; s_besaran = {W_DER{1'b0}};
        repeat (4) @(posedge clk);
        rst_n = 1'b1;
        i_enable = 1'b1;
        @(posedge clk);

        // one accepted word per cycle
        for (drive_n = 0; drive_n < limit_n; drive_n = drive_n + 1) begin
            @(negedge clk);
            s_tdata      = {1'b0, mem_win[drive_n][31:0]};
            s_hp         = mem_hp[drive_n][W_HP-1:0];
            s_besaran    = mem_der[drive_n][W_DER-1:0];
            s_sample_idx = drive_n[W_IDX-1:0];
            s_tuser      = {W_TUSER{1'b0}};
            s_tvalid     = 1'b1;
            s_tlast      = (drive_n == (limit_n - 1));
        end
        @(negedge clk);
        s_tvalid = 1'b0;
        s_tlast  = 1'b0;
        // drain: the stage has a fixed small latency, so leave room for the tail events
        repeat (12) @(posedge clk);
        done = 1'b1;
    end

    // accepted word count and the sticky overflow flag
    always @(posedge clk) begin
        if (rst_n && i_enable) begin
            if (m_tvalid) begin
                // the word path must be forwarded verbatim: the word leaving with an index
                // is the word that entered with that index, one word per accepted sample
                if (out_n < N_MAX) begin
                    if (m_sample_idx !== out_n[W_IDX-1:0])             mm_fwd_i <= mm_fwd_i + 1;
                    if (m_tdata      !== {1'b0, mem_win[out_n][31:0]}) mm_fwd_d <= mm_fwd_d + 1;
                    if (m_tuser      !== {W_TUSER{1'b0}})              mm_fwd_u <= mm_fwd_u + 1;
                    if (m_tlast      !== (out_n == (limit_n - 1)))     mm_fwd_t <= mm_fwd_t + 1;
                end
                out_n <= out_n + 1;
            end
            if (m_overflow)  ovf_n   <= ovf_n + 1;
            if (d_dbg_valid) dbg_v_n <= dbg_v_n + 1;
        end
    end

    // event stream monitor: order preserving, the events arrive in peak order
    always @(posedge clk) begin
        if (rst_n && i_enable && m_ev_valid) begin
            if (ev_n < P_MAX) begin
                if (m_ev_idx !== exp_pos[ev_n][W_IDX-1:0]) begin
                    mm_idx <= mm_idx + 1;
                    if (mm_idx <= 5)
                        $display("tb_peak_detect: idx  ev %0d got %0d want %0d",
                                 ev_n, m_ev_idx, exp_pos[ev_n]);
                end
                if (m_ev_val !== exp_pv[ev_n]) begin
                    mm_val <= mm_val + 1;
                    if (mm_val <= 5)
                        $display("tb_peak_detect: val  ev %0d got %0d want %0d",
                                 ev_n, m_ev_val, exp_pv[ev_n]);
                end
                if ((m_ev_kind == afib_lite_pkg::EV_QRS) !== (exp_isqrs[ev_n] != 0)) begin
                    mm_kind <= mm_kind + 1;
                    if (mm_kind <= 5)
                        $display("tb_peak_detect: kind ev %0d got %0d want beat %0d",
                                 ev_n, m_ev_kind, exp_isqrs[ev_n]);
                end
                if (m_ev_kind == afib_lite_pkg::EV_QRS) ev_beat_seen <= ev_beat_seen + 32'd1;
                // four way class parity against the golden event_kind column
                if (cls_w !== exp_kind[ev_n][1:0]) begin
                    mm_cls <= mm_cls + 1;
                    if (mm_cls <= 5)
                        $display("tb_peak_detect: class ev %0d got %0d want %0d",
                                 ev_n, cls_w, exp_kind[ev_n][1:0]);
                end
                flag_census[cls_w] <= flag_census[cls_w] + 32'd1;
                // a walk row: the golden table carries the peak position in sample_index and the
                // beat position in qrs_sample_index; record when the event carries the beat
                if ((cls_w == 2'd1) && (m_ev_idx == exp_qrsidx[ev_n][W_IDX-1:0]) &&
                    (m_ev_idx !== exp_pos[ev_n][W_IDX-1:0]))
                    mm_idx_beat <= mm_idx_beat + 32'd1;
                case (m_ev_kind)
                    afib_lite_pkg::EV_QRS:       ev_kind_census[0] <= ev_kind_census[0] + 32'd1;
                    afib_lite_pkg::EV_PEAK_CAND: ev_kind_census[1] <= ev_kind_census[1] + 32'd1;
                    default:                     ev_kind_census[2] <= ev_kind_census[2] + 32'd1;
                endcase
                ev_n <= ev_n + 1;
            end else begin
                mm_kind <= mm_kind + 1;
                if (mm_kind <= 5)
                    $display("tb_peak_detect: extra event %0d beyond the expected %0d",
                             ev_n, P_MAX);
                ev_n <= ev_n + 1;
            end
        end

        // introspection: i1 and pk_f at each processed peak
        if (rst_n && i_enable && d_valid) begin
            if (dv_n < P_MAX) begin
                if (d_thr !== exp_i1[dv_n][W_THR-1:0]) begin
                    mm_thr <= mm_thr + 1;
                    if (mm_thr <= 5)
                        $display("tb_peak_detect: d_thr ev %0d got %0d want %0d",
                                 dv_n, d_thr, exp_i1[dv_n]);
                end
                if (d_pk !== exp_pkf[dv_n][W_THR-1:0]) begin
                    mm_pk <= mm_pk + 1;
                    if (mm_pk <= 5)
                        $display("tb_peak_detect: d_pk  ev %0d got %0d want %0d",
                                 dv_n, d_pk, exp_pkf[dv_n]);
                end
                dv_n <= dv_n + 1;
            end else begin
                dv_n <= dv_n + 1;
            end
        end
    end

    // -----------------------------------------------------------------------
    // verdict
    // -----------------------------------------------------------------------
    integer ninetofnine;
    integer dbg_mm;
    integer k;
    reg [31:0] got_amb;

    initial begin
        wait (done == 1'b1);
        #1;

        $display("tb_peak_detect: run limit %0d samples, accepted words %0d", limit_n, out_n);
        $display("tb_peak_detect: expected peaks %0d, events seen %0d, introspection pulses %0d",
                 expect_k, ev_n, dv_n);
        $display("tb_peak_detect: loaded census 4way {qrs %0d, search_back %0d, rejected_t %0d, noise %0d}",
                 ev_loaded_census[0], ev_loaded_census[1],
                 ev_loaded_census[2], ev_loaded_census[3]);
        $display("tb_peak_detect: event bus census {EV_QRS %0d, EV_PEAK_CAND %0d, other %0d}, beats %0d",
                 ev_kind_census[0], ev_kind_census[1], ev_kind_census[2], ev_beat_seen);
        $display("tb_peak_detect: mismatches idx %0d val %0d kind %0d d_thr %0d d_pk %0d",
                 mm_idx, mm_val, mm_kind, mm_thr, mm_pk);
        $display("tb_peak_detect: forwarded word mismatches idx %0d data %0d user %0d last %0d, d_dbg_valid pulses %0d",
                 mm_fwd_i, mm_fwd_d, mm_fwd_u, mm_fwd_t, dbg_v_n);
        $display("tb_peak_detect: four way class checkpoints %0d, class mismatches %0d", ev_n, mm_cls);
        $display("tb_peak_detect: flag word census {qrs %0d, search_back %0d, rejected_t %0d, noise %0d}",
                 flag_census[0], flag_census[1], flag_census[2], flag_census[3]);
        $display("tb_peak_detect: walk rows carrying the beat index instead of the peak index %0d",
                 mm_idx_beat);
        $display("tb_peak_detect: o_beat_count %0d", o_beat_count);
        $display("tb_peak_detect: m_overflow cycles %0d (0 expected, reported not gated)", ovf_n);

        // checkpoint count: one per peak event index plus one per peak introspection pair
        $display("tb_peak_detect: threshold checkpoints compared %0d (d_thr) + %0d (d_pk) = %0d",
                 dv_n, dv_n, 2*dv_n);

        // the nine way ambang_state, comparing the counter words of the introspection bus
        ninetofnine = 1;
        dbg_mm = 0;
        if (limit_n == N_MAX) begin
            for (k = 0; k < A_MAX; k = k + 1) begin
                got_amb = d_dbg[k*32 +: 32];
                if (got_amb !== exp_amb[k]) begin
                    dbg_mm = dbg_mm + 1;
                    $display("tb_peak_detect: ambang_state[%0d] got %0d want %0d",
                             k, got_amb, exp_amb[k]);
                end
            end
            if (dbg_mm != 0) ninetofnine = 0;
            // the same nine words as a multiset, so an ordering difference is visible
            $display("tb_peak_detect: ambang_state compared %0d of %0d, mismatches %0d",
                     A_MAX, A_MAX, dbg_mm);
            $display("tb_peak_detect: ambang_state got  [%0d, %0d, %0d, %0d, %0d, %0d, %0d, %0d, %0d]",
                     d_dbg[0*32 +: 32], d_dbg[1*32 +: 32], d_dbg[2*32 +: 32],
                     d_dbg[3*32 +: 32], d_dbg[4*32 +: 32], d_dbg[5*32 +: 32],
                     d_dbg[6*32 +: 32], d_dbg[7*32 +: 32], d_dbg[8*32 +: 32]);
            $display("tb_peak_detect: ambang_state want [%0d, %0d, %0d, %0d, %0d, %0d, %0d, %0d, %0d]",
                     exp_amb[0], exp_amb[1], exp_amb[2], exp_amb[3], exp_amb[4],
                     exp_amb[5], exp_amb[6], exp_amb[7], exp_amb[8]);
        end else begin
            $display("tb_peak_detect: ambang_state NOT compared (+LIMIT smoke pass)");
        end

        if (ev_n != expect_k) begin
            $display("tb_peak_detect: FAIL event count got %0d want %0d", ev_n, expect_k);
            $fatal(1);
        end
        if (out_n != limit_n) begin
            $display("tb_peak_detect: FAIL accepted word count got %0d want %0d", out_n, limit_n);
            $fatal(1);
        end
        if ((mm_idx != 0) || (mm_val != 0) || (mm_kind != 0)) begin
            $display("tb_peak_detect: FAIL event stream idx %0d val %0d kind %0d",
                     mm_idx, mm_val, mm_kind);
            $fatal(1);
        end
        if ((mm_thr != 0) || (mm_pk != 0)) begin
            $display("tb_peak_detect: FAIL introspection d_thr %0d d_pk %0d", mm_thr, mm_pk);
            $fatal(1);
        end
        if (mm_cls != 0) begin
            $display("tb_peak_detect: FAIL four way class mismatches %0d", mm_cls);
            $fatal(1);
        end
        if ((mm_fwd_i != 0) || (mm_fwd_d != 0) || (mm_fwd_u != 0) || (mm_fwd_t != 0)) begin
            $display("tb_peak_detect: FAIL word forwarding idx %0d data %0d user %0d last %0d",
                     mm_fwd_i, mm_fwd_d, mm_fwd_u, mm_fwd_t);
            $fatal(1);
        end
        if (dbg_v_n != dv_n) begin
            $display("tb_peak_detect: FAIL d_dbg_valid pulses %0d want %0d", dbg_v_n, dv_n);
            $fatal(1);
        end
        if (limit_n == N_MAX) begin
            if (ev_beat_seen != 32'd2596) begin
                $display("tb_peak_detect: FAIL beats got %0d want 2596", ev_beat_seen);
                $fatal(1);
            end
            if (o_beat_count != 32'd2596) begin
                $display("tb_peak_detect: FAIL o_beat_count got %0d want 2596", o_beat_count);
                $fatal(1);
            end
            if (flag_census[0] != 32'd2590 || flag_census[1] != 32'd6 ||
                flag_census[2] != 32'd1909 || flag_census[3] != 32'd272) begin
                $display("tb_peak_detect: FAIL flag census {qrs %0d, search_back %0d, rejected_t %0d, noise %0d} want {2590, 6, 1909, 272}",
                         flag_census[0], flag_census[1], flag_census[2], flag_census[3]);
                $fatal(1);
            end
            if (ninetofnine != 1) begin
                $display("tb_peak_detect: FAIL ambang_state mismatches %0d of 9", dbg_mm);
                $fatal(1);
            end
        end
        $display("tb_peak_detect: PASS");
        $finish;
    end

endmodule

`default_nettype wire
